# IAR project libsrtp2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; CONFIG_BUILD_RAM=1; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; _NO_DEFINITIONS_IN_HEADER_FILES; HAVE_CONFIG_H; KVS_PLAT_RTK_FREERTOS
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\iar_include; ..\..\..\lib_amazon\libsrtp\crypto\include; ..\..\..\lib_amazon\libsrtp\include; ..\..\..\lib_amazon\libsrtp; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.4.3\include; ..\..\..\component\os\freertos\freertos_v10.4.3_port\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api\wifi; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\cmsis\cmsis-core\include; ..\..\..\component\soc\realtek\8195b\app\rtl_printf\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\app\stdio_port; ..\..\..\component\soc\realtek\8195b\misc\utilities\include; ..\..\..\component\soc\realtek\8195b\mbed-hal\hal_ext; ..\..\..\component\soc\realtek\8195b\mbed-hal\targets\hal\rtl8195bh; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\include\usb_otg; ..\..\..\component\soc\realtek\8195b\fwlib\hal-rtl8195b-hp\lib\video\isp\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include; ..\..\..\component\common\network\ssl\ssl_ram_map\rom
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_mmf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group crypto/cipher
    ../../../lib_amazon/libsrtp/crypto/cipher/: aes.c aes_gcm_mbedtls.c aes_icm.c aes_icm_mbedtls.c cipher.c null_cipher.c
  group crypto/hash
    ../../../lib_amazon/libsrtp/crypto/hash/: auth.c hmac.c hmac_mbedtls.c null_auth.c sha1.c
  group crypto/kernel
    ../../../lib_amazon/libsrtp/crypto/kernel/: alloc.c crypto_kernel.c err.c key.c
  group crypto/math
    ../../../lib_amazon/libsrtp/crypto/math/: datatypes.c stat.c
  group crypto/replay
    ../../../lib_amazon/libsrtp/crypto/replay/: rdb.c rdbx.c ut_sim.c
  group srtp
    ../../../lib_amazon/libsrtp/srtp/: ekt.c srtp.c
