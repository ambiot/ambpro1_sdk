# IAR project lib_kvs_Webrtc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: __thumb2__; CONFIG_PLATFORM_8195BHP; __FPU_PRESENT; __ARM_ARCH_7M__=0; __ARM_ARCH_8M_MAIN__=1; __ARM_ARCH_8M_BASE__=0; CONFIG_BUILD_RAM=1; _NO_DEFINITIONS_IN_HEADER_FILES; __IEEE_LITTLE_ENDIAN; KVS_USE_MBEDTLS; KVS_BUILD_WITH_LWS; KVS_PLAT_RTK_FREERTOS; LWS_RTK_PLATFORM; LWS_AMAZON_RTOS; BUILD_CLIENT; ENABLE_STREAMING; ENABLE_DATA_CHANNEL___
  ICCARM.IExtraOptions: --cmse; --enum_is_int; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\lib_amazon\iar_include; ..\..\..\component\os\os_dep\include; ..\..\..\component\common\api; ..\..\..\component\common\api\platform; ..\..\..\component\common\api\network\include; ..\..\..\component\common\api\wifi; ..\..\..\component\common\network\ssl\mbedtls-2.16.6\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\posix; ..\..\..\component\common\network\lwip\lwip_v2.0.2\src\include\lwip; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek\freertos; ..\..\..\component\common\network\lwip\lwip_v2.0.2\port\realtek; ..\..\..\component\common\network\ssl\ssl_ram_map\rom; ..\..\..\component\os\freertos\posix\lib\include; ..\..\..\component\os\freertos\posix\lib\FreeRTOS-Plus-POSIX\include\portable\realtek\rtl8195; ..\..\..\component\os\freertos\posix\lib\FreeRTOS-Plus-POSIX\include; ..\..\..\component\os\freertos\posix\lib\include\FreeRTOS_POSIX; ..\..\..\component\os\freertos\posix\lib\include\private; ..\..\..\component\os\freertos; ..\..\..\component\os\freertos\freertos_v10.4.3\include; ..\..\..\component\os\freertos\freertos_v10.4.3_port\IAR\ARM_CM33_NTZ\non_secure; ..\..\..\component\soc\realtek\8195b\cmsis\rtl8195b-hp\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-producer-c\src\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\client\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\common\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\utils\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\heap\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\state\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\trace\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\view\include; ..\..\..\lib_amazon\amazon-kinesis-video-streams-pic\src\mkvgen\include; ..\..\..\lib_amazon\libwebsockets\include; ..\..\..\lib_amazon\libwebsockets; ..\..\..\lib_amazon\amazon-kinesis-video-streams-webrtc-sdk-c\src\include; ..\..\..\lib_amazon\libsrtp\include; ..\..\..\component\common\file_system\fatfs\r0.14; ..\..\..\component\common\file_system\fatfs; ..\..\..\lib_amazon\libusrsctp\usrsctplib; ..\..\..\lib_amazon\libusrsctp\usrsctplib\netinet; ..\..\..\lib_amazon\libusrsctp\usrsctplib\netinet6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: lib_mmf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group crypto
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Crypto/: Dtls.c Dtls_mbedtls.c IOBuffer.c Tls.c Tls_mbedtls.c
  group ice
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Ice/: ConnectionListener.c IceAgent.c IceAgentStateMachine.c IceUtils.c NatBehaviorDiscovery.c Network.c SocketConnection.c TurnConnection.c
  group metrics
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Metrics/: Metrics.c
  group PeerConnection
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/PeerConnection/: DataChannel.c JitterBuffer.c jsmn.c PeerConnection.c Retransimitter.c Rtcp.c Rtp.c SessionDescription.c
  group Rtcp
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Rtcp/: RollingBuffer.c RtcpPacket.c RtpRollingBuffer.c
  group Rtp
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Rtp/: RtpPacket.c
  group Rtp/Codecs
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Rtp/Codecs/: RtpG711Payloader.c RtpH264Payloader.c RtpOpusPayloader.c RtpVP8Payloader.c
  group Sctp
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Sctp/: Sctp.c
  group Sdp
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Sdp/: Deserialize.c Serialize.c
  group signaling
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Signaling/: ChannelInfo.c Client.c FileCache.c LwsApiCalls.c Signaling.c StateMachine.c
  group Srtp
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Srtp/: SrtpSession.c
  group Stun
    ../../../lib_amazon/amazon-kinesis-video-streams-webrtc-sdk-c/src/source/Stun/: Stun.c
